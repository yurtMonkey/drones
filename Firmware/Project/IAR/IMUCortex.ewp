# IAR project IMUCortex.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B90
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; C:\Stellarisware
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: IMUCortex.bin
  ILINK.IlinkOutputFile: IMUCortex.out
  ILINK.IlinkIcfFile: IMUCortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Libraries
    ../../Lib/: driverlib9B90.a
  group Source
    ../../Source/: adcdriver.c AileronCtrl.cpp cordic.c DCM.cpp ElevatorCtrl.cpp GPS.cpp log.c main.c mmc.c nav.cpp ppmdriver.cpp RudderCtrl.cpp servodriver.c startup_ewarm.c Telemetry.cpp tff.c ThrottleCtrl.cpp tick.c uartdriver.c vmath.cpp
